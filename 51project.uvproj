# Keil uVision project 51project.uvproj, settings and files
target 51project (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\src\app;.\src\driver;.\src\include
  group include
    ./src/include/: buzzer.h ds18b20.h ds1302.h key.h uart.h 1602.h
  group driver
    ./src/driver/: buzzer.c ds18b20.c ds1302.c key.c uart.c 1602.c
  group startup
    ./: STARTUP.A51
